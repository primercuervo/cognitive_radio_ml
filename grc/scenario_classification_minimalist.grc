<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>final_classification_minimalist</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>subchan_map</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchan</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nguard_bins</value></param>
<param><key>comment</key><value>per side of the band</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>256 * 8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pu_frame_len</value></param>
<param><key>value</key><value>80*5*9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1e7)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len</value></param>
<param><key>comment</key><value>at 10 MS/s</value></param>
<param><key>value</key><value>(su_frame_len_low_rate + len(taps))* 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len_low_rate</value></param>
<param><key>comment</key><value>calculated for 256 byte payload</value></param>
<param><key>value</key><value>sync.get_frame_samps(True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*6, [1,]*116, [0,]*6))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0 </value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()-1</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))</value></param>
<param><key>bands</key><value>nchan</value></param>
<param><key>guard</key><value>nguard_bins</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 12) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>np.array([0.003524782368913293, 0.002520402194932103, -3.532667373554307e-17, -0.0025783423334360123, -0.0036887258756905794, -0.0026390093844383955, -3.7046301165340785e-18, 0.0027025998570024967, 0.003868663916364312, 0.0027693307492882013, -9.712380039780164e-18, -0.0028394402470439672, -0.004067056812345982, -0.0029131921473890543, 2.454170927498071e-17, 0.0029908770229667425, 0.004286897834390402, 0.0030728192068636417, -9.712380039780164e-18, -0.0031593774911016226, -0.004531863145530224, -0.0032509532757103443, -6.861573196148834e-18, 0.0033479968551546335, 0.004806521814316511, 0.003451012307778001, -9.712380039780164e-18, -0.0035605679731816053, -0.005116619635373354, -0.0036773078609257936, 2.849619674016194e-17, 0.003801962360739708, 0.005469490308314562, 0.003935364540666342, -9.712380039780164e-18, -0.004078468773514032, -0.0058746375143527985, -0.004232373554259539, -1.196125168755972e-17, 0.004398348741233349, 0.006344608962535858, 0.004577873274683952, -9.712380039780164e-18, -0.004772676154971123, -0.0068963137455284595, -0.004984795115888119, 3.532667373554307e-17, 0.005216646008193493, 0.00755310570821166, 0.005471116863191128, -9.712380039780164e-18, -0.0057516866363584995, -0.00834816973656416, -0.00606258912011981, 9.712380039780164e-18, 0.006409022491425276, 0.009330307133495808, 0.006797448266297579, -9.712380039780164e-18, -0.007235993165522814, -0.010574348270893097, -0.007735027000308037, 9.712380039780164e-18, 0.008307991549372673, 0.012201170437037945, 0.008972631767392159, -9.712380039780164e-18, -0.00975286029279232, -0.014419564977288246, -0.010681704618036747, 9.712380039780164e-18, 0.011806094087660313, 0.017623912543058395, 0.013195047155022621, -9.712380039780164e-18, -0.01495438627898693, -0.022659316658973694, -0.017255060374736786, 9.712380039780164e-18, 0.020392345264554024, 0.03172304481267929, 0.02492397651076317, -9.712380039780164e-18, -0.03204511106014252, -0.052871737629175186, -0.04486315697431564, 9.712380039780164e-18, 0.0747719332575798, 0.15861520171165466, 0.22431577742099762, 0.24915219843387604, 0.22431577742099762, 0.15861520171165466, 0.0747719332575798, 9.712380039780164e-18, -0.04486315697431564, -0.052871737629175186, -0.03204511106014252, -9.712380039780164e-18, 0.02492397651076317, 0.03172304481267929, 0.020392345264554024, 9.712380039780164e-18, -0.017255060374736786, -0.022659316658973694, -0.01495438627898693, -9.712380039780164e-18, 0.013195047155022621, 0.017623912543058395, 0.011806094087660313, 9.712380039780164e-18, -0.010681704618036747, -0.014419564977288246, -0.00975286029279232, -9.712380039780164e-18, 0.008972631767392159, 0.012201170437037945, 0.008307991549372673, 9.712380039780164e-18, -0.007735027000308037, -0.010574348270893097, -0.007235993165522814, -9.712380039780164e-18, 0.006797448266297579, 0.009330307133495808, 0.006409022491425276, 9.712380039780164e-18, -0.00606258912011981, -0.00834816973656416, -0.0057516866363584995, -9.712380039780164e-18, 0.005471116863191128, 0.00755310570821166, 0.005216646008193493, 3.532667373554307e-17, -0.004984795115888119, -0.0068963137455284595, -0.004772676154971123, -9.712380039780164e-18, 0.004577873274683952, 0.006344608962535858, 0.004398348741233349, -1.196125168755972e-17, -0.004232373554259539, -0.0058746375143527985, -0.004078468773514032, -9.712380039780164e-18, 0.003935364540666342, 0.005469490308314562, 0.003801962360739708, 2.849619674016194e-17, -0.0036773078609257936, -0.005116619635373354, -0.0035605679731816053, -9.712380039780164e-18, 0.003451012307778001, 0.004806521814316511, 0.0033479968551546335, -6.861573196148834e-18, -0.0032509532757103443, -0.004531863145530224, -0.0031593774911016226, -9.712380039780164e-18, 0.0030728192068636417, 0.004286897834390402, 0.0029908770229667425, 2.454170927498071e-17, -0.0029131921473890543, -0.004067056812345982, -0.0028394402470439672, -9.712380039780164e-18, 0.0027693307492882013, 0.003868663916364312, 0.0027025998570024967, -3.7046301165340785e-18, -0.0026390093844383955, -0.0036887258756905794, -0.0025783423334360123, -3.532667373554307e-17, 0.002520402194932103])*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold_delta</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>nterframe_time_ch_1_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>terframe_time_ch_2_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>variance_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>file</key><value>packet_rate_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_2</value></param>
<param><key>file</key><value>nterframe_time_ch4_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_3</value></param>
<param><key>file</key><value>nterframe_time_ch_3_scn_0.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/cuervo/thesis/data/final_pu/no_dc/scn_5_snr_15.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>4500</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>classifier_energy_detection_vcf</key>
<param><key>id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>buff_size</key><value>1000</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>threshold_delta_db</key><value>threshold_delta</value></param>
</block>
<block>
<key>classifier_feature_extraction_f</key>
<param><key>id</key><value>classifier_feature_extraction_f_0</value></param>
<param><key>frame_len</key><value>pu_frame_len / nfft</value></param>
<param><key>nframes</key><value>50</value></param>
<param><key>sample_rate</key><value>samp_rate / nfft</value></param>
<param><key>stepsize</key><value>5</value></param>
</block>
<block>
<key>classifier_frame_detection_f</key>
<param><key>id</key><value>classifier_frame_detection_f_0</value></param>
<param><key>lookahead</key><value>5</value></param>
<param><key>su_frame_len</key><value>su_frame_len/nfft - 9</value></param>
<param><key>tolerance</key><value>5</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_file_sink_0_0_3</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_file_sink_0_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>classifier_energy_detection_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
